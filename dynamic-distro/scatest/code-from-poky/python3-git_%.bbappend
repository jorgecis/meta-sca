inherit sca

DEPENDS += "python3-pyre-native"